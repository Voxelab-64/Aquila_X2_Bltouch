# Keil uVision project voxelab.uvprojx, settings and files
target firmware_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  .\bin\firmware.bin  .\obj\firmware.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,__STM32F1__,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32
  c misc: --gnu --diag_suppress=186,66 --cpp11
  c include: ..\source\compoment\adc;..\source\compoment\i2c;..\source\compoment\sdio;..\source\compoment\sdio\sd_card\inc;..\source\compoment\spi;..\source\compoment\uart;..\source\compoment\Utility;..\source\drivers\board;..\source\drivers\library;..\source\drivers\library\inc;..\source\framework\cores;..\source\framework\usb;..\source\framework\variants;..\source\main;..\source\main\hdsc32core;..\source\marlin;..\source\marlin\src;..\source\marlin\src\pins;..\source\marlin\src\core;..\source\marlin\src\feature;..\source\marlin\src\feature\bedlevel;..\source\marlin\src\feature\bedlevel\abl;..\source\marlin\src\feature\bedlevel\mbl;..\source\marlin\src\feature\bedlevel\ubl;..\source\marlin\src\feature\digipot;..\source\marlin\src\feature\leds;..\source\marlin\src\feature\mmu2;..\source\marlin\src\feature\touch;..\source\marlin\src\gcode;..\source\marlin\src\HAL;..\source\marlin\src\HAL\shared;..\source\marlin\src\HAL\shared\backtrace;..\source\marlin\src\HAL\STM32F1;..\source\marlin\src\HAL\STM32F1\dogm;..\source\marlin\src\HAL\STM32F1\inc;..\source\marlin\src\inc;..\source\marlin\src\lcd;..\source\marlin\src\lcd\dogm;..\source\marlin\src\lcd\dogm\fontdata;..\source\marlin\src\lcd\dwin;..\source\marlin\src\lcd\language;..\source\marlin\src\lcd\menu;..\source\marlin\src\lcd\menu\game;..\source\marlin\src\libs;..\source\marlin\src\module;..\source\marlin\src\module\stepper;..\source\marlin\src\module\thermistor;..\source\marlin\src\pins;..\source\marlin\src\pins\stm32f1;..\source\marlin\src\sd;..\source\marlin\src\sd\usb_flashdrive;..\source\marlin\src\sd\usb_flashdrive\lib-uhs2;..\source\marlin\src\lcd\extui;..\source\marlin\src\lcd\extui\lib\anycubic;..\source\marlin\src\lcd\extui\lib\dgus;..\source\marlin\src\lcd\extui\lib\dgus\fysetc;..\source\marlin\src\lcd\extui\lib\dgus\hiprecy;..\source\marlin\src\lcd\extui\lib\dgus\origin;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\archim2-flash;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\basic;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended\unicode;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extras;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\language;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\screens;..\source\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\theme;..\source\marlin\src\lcd\extui\\lib\mks_ui;..\source\marlin\src\lcd\HD44780;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\dyn_SWI;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\UHS_BULK_STORAGE;..\source\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\USB_HOST_SHIELD;..\source\marlin\src\libs\heatshrink;..\source\marlin\src\libs\L64XX
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x10000
  link misc: --keep=*Handler
  group compoment
    ../source/compoment/adc/: adc.h
    ../source/compoment/i2c/: i2c.h
    ../source/compoment/sdio/: sdio_f1.h sdio_hal.h
    ../source/compoment/Utility/: rtdef.h
  group drivers
    ../source/drivers/library/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group board
    ../source/drivers/board/: board_cfg.h board_extint.c board_gpio.c board_gpio.h board_tim0.h startup.cpp startup.h Servo_timer.c
  group startup
    ../source/main/: ddl_config.h main.cpp
    ../source/main/hdsc32core/: core_cm4.h hc32_common.h hc32_ddl.h hc32f460petb.h startup_hc32f460petb.s stdint.h stdio.h system_hc32f460petb.c system_hc32f460petb.h
    ./: f.lib
  group core
    ../source/framework/cores/: Arduino.h bit_constants.h bitband.h bits.h Client.h dtostrf.h HardwareSerial.h io.h itoa.h iwdg.c iwdg.h libmaple.h libmaple_types.h pgmspace.h pins_arduino.h Print.h ring_buffer.h Server.h spi.h spi_private.h spi1.h Stream.h Udp.h usart.h WCharacter.h wirish.h wirish_math.h wirish_time.h wirish_types.h WString.h usart.c
  group marlin
    ../source/Marlin/: Configuration.h Configuration_adv.h Version.h
    ../source/Marlin/src/: MarlinCore.cpp MarlinCore.h
  group marlin_cores
    ../source/Marlin/src/core/: utility.cpp utility.h serial.cpp serial.h language.h macros.h types.h boards.h multi_language.h debug_out.h drivers.h millis_t.h debug_section.h multi_language.cpp
  group marlin_feature
    ../source/Marlin/src/feature/: babystep.cpp babystep.h closedloop.h fwretract.h pause.h backlash.cpp backlash.h baricuda.cpp baricuda.h binary_protocol.cpp binary_protocol.h bltouch.cpp bltouch.h cancel_object.cpp cancel_object.h caselight.cpp caselight.h closedloop.cpp controllerfan.cpp controllerfan.h direct_stepping.cpp direct_stepping.h e_parser.cpp e_parser.h encoder_i2c.cpp encoder_i2c.h fanmux.cpp fanmux.h filwidth.cpp filwidth.h fwretract.cpp host_actions.cpp host_actions.h hotend_idle.cpp hotend_idle.h joystick.cpp joystick.h max7219.cpp max7219.h mixing.cpp mixing.h pause.cpp power.cpp power.h power_monitor.cpp power_monitor.h powerloss.cpp powerloss.h probe_temp_comp.cpp probe_temp_comp.h runout.cpp runout.h snmm.cpp snmm.h solenoid.cpp solenoid.h spindle_laser.cpp spindle_laser.h spindle_laser_types.h tmc_util.cpp tmc_util.h twibus.cpp twibus.h z_stepper_align.cpp z_stepper_align.h
    ../source/Marlin/src/feature/bedlevel/: bedlevel.cpp bedlevel.h
    ../source/Marlin/src/feature/bedlevel/mbl/: mesh_bed_leveling.cpp mesh_bed_leveling.h
    ../source/Marlin/src/feature/bedlevel/ubl/: ubl.cpp ubl.h ubl_G29.cpp ubl_motion.cpp
    ../source/Marlin/src/feature/digipot/: digipot.h digipot_mcp4018.cpp digipot_mcp4451.cpp
    ../source/Marlin/src/feature/leds/: blinkm.cpp blinkm.h leds.cpp leds.h neopixel.cpp neopixel.h pca9533.cpp pca9533.h pca9632.cpp pca9632.h printer_event_leds.cpp printer_event_leds.h tempstat.cpp tempstat.h
    ../source/Marlin/src/feature/mmu2/: mmu2.cpp mmu2.h
    ../source/Marlin/src/feature/touch/: xpt2046.cpp xpt2046.h
    ../source/Marlin/src/feature/bedlevel/abl/: abl.cpp
  group marlin_gcode
    ../source/Marlin/src/gcode/: gcode.cpp gcode.h parser.cpp parser.h queue.cpp queue.h
    ../source/Marlin/src/gcode/calibrate/: G28.cpp G33.cpp G34_M422.cpp G76_M871.cpp G425.cpp M12.cpp M48.cpp M100.cpp M425.cpp M665.cpp M666.cpp M852.cpp
    ../source/Marlin/src/gcode/config/: M92.cpp M200-M205.cpp M220.cpp M221.cpp M301.cpp M302.cpp M304.cpp M43.cpp M217.cpp M218.cpp M281.cpp M305.cpp M540.cpp M575.cpp M672.cpp
    ../source/Marlin/src/gcode/control/: M17_M18_M84.cpp M42.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M226.cpp M400.cpp M997.cpp M999.cpp T.cpp M3-M5.cpp M7-M9.cpp M280.cpp M350_M351.cpp M380_M381.cpp M605.cpp
    ../source/Marlin/src/gcode/eeprom/: M500-M504.cpp
    ../source/Marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../source/Marlin/src/gcode/lcd/: M0_M1.cpp M117.cpp M145.cpp M250.cpp M300.cpp M73.cpp
    ../source/Marlin/src/gcode/host/: M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp M16.cpp M360.cpp M876.cpp
    ../source/Marlin/src/gcode/motion/: G0_G1.cpp G4.cpp M290.cpp G2_G3.cpp G5.cpp G6.cpp G80.cpp
    ../source/Marlin/src/gcode/geometry/: G92.cpp M206_M428.cpp G17-G19.cpp G53-G59.cpp
    ../source/Marlin/src/gcode/units/: M82_M83.cpp G20_G21.cpp M149.cpp
    ../source/Marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../source/Marlin/src/gcode/bedlevel/abl/: G29.cpp M421.cpp
    ../source/Marlin/src/gcode/bedlevel/: G26.cpp G35.cpp G42.cpp M420.cpp
    ../source/Marlin/src/gcode/feature/advance/: M900.cpp
    ../source/Marlin/src/gcode/feature/baricuda/: M126-M129.cpp
    ../source/Marlin/src/gcode/feature/camera/: M240.cpp
    ../source/Marlin/src/gcode/feature/cancel/: M486.cpp
    ../source/Marlin/src/gcode/feature/caselight/: M355.cpp
    ../source/Marlin/src/gcode/feature/clean/: G12.cpp
    ../source/Marlin/src/gcode/feature/controllerfan/: M710.cpp
    ../source/Marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../source/Marlin/src/gcode/feature/filwidth/: M404-M407.cpp
    ../source/Marlin/src/gcode/feature/fwretract/: G10_G11.cpp M207-M209.cpp
    ../source/Marlin/src/gcode/feature/i2c/: M260_M261.cpp
    ../source/Marlin/src/gcode/feature/L6470/: M122.cpp M906.cpp M916-918.cpp
    ../source/Marlin/src/gcode/feature/leds/: M150.cpp M7219.cpp
    ../source/Marlin/src/gcode/feature/macro/: M810-M819.cpp
    ../source/Marlin/src/gcode/feature/mixing/: M163-M165.cpp M166.cpp
    ../source/Marlin/src/gcode/feature/pause/: G27.cpp G60.cpp G61.cpp M125.cpp M600.cpp M603.cpp M701_M702.cpp
    ../source/Marlin/src/gcode/feature/power_monitor/: M430.cpp
    ../source/Marlin/src/gcode/feature/prusa_MMU2/: M403.cpp
    ../source/Marlin/src/gcode/feature/runout/: M412.cpp
    ../source/Marlin/src/gcode/feature/trinamic/: M569.cpp M911-M914.cpp
    ../source/Marlin/src/gcode/probe/: G30.cpp G31_G32.cpp G38.cpp M401_M402.cpp M851.cpp M951.cpp
    ../source/Marlin/src/gcode/scara/: M360-M364.cpp
    ../source/Marlin/src/gcode/sd/: M33.cpp M34.cpp M1001.cpp M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M524.cpp M928.cpp
    ../source/Marlin/src/gcode/temp/: M141_M191.cpp M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M155.cpp M303.cpp
  group marlin_HAL
    ../source/Marlin/src/HAL/: HAL.h platforms.h
    ../source/Marlin/src/HAL/shared/: Delay.h HAL_SPI.h Marduino.h math_32bit.h eeprom_api.cpp eeprom_api.h eeprom_if.h eeprom_if_i2c.cpp eeprom_if_spi.cpp esp_wifi.cpp esp_wifi.h HAL_spi_L6470.cpp HAL_ST7920.h
    ../source/Marlin/src/HAL/shared/backtrace/: backtrace.cpp backtrace.h unwarm.cpp unwarm.h unwarm_arm.cpp unwarm_thumb.cpp unwarmbytab.cpp unwarmbytab.h unwarmmem.cpp unwarmmem.h unwinder.cpp unwinder.h unwmemaccess.cpp unwmemaccess.h
    ../source/Marlin/src/HAL/STM32F1/: eeprom_bl24cxx.cpp eeprom_flash.cpp eeprom_if_iic.cpp eeprom_sdcard.cpp eeprom_wired.cpp endstop_interrupts.h fastio.h HAL.cpp HAL_SPI.cpp msc_sd.cpp msc_sd.h onboard_sd.cpp onboard_sd.h pinsDebug.h sdio.cpp sdio.h SoftwareSerial.cpp SoftwareSerial.h SPI.cpp SPI.h spi_pins.h timers.cpp timers.h watchdog.cpp watchdog.h Servo.cpp
    ../source/Marlin/src/HAL/STM32F1/dogm/: u8g_com_stm32duino_fsmc.cpp u8g_com_stm32duino_swspi.cpp
    ../source/Marlin/src/HAL/STM32F1/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
  group marlin_inc
    ../source/Marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group marlin_lcd
    ../source/Marlin/src/lcd/: fontutils.cpp fontutils.h lcdprint.cpp lcdprint.h thermistornames.h ultralcd.cpp ultralcd.h extui_anycubic_tft.cpp extui_dgus_lcd.cpp extui_example.cpp extui_malyan_lcd.cpp
    ../source/Marlin/src/lcd/menu/: menu.cpp menu.h menu_addon.h menu_advanced.cpp menu_backlash.cpp menu_bed_corners.cpp menu_bed_leveling.cpp menu_cancelobject.cpp menu_configuration.cpp menu_custom.cpp menu_delta_calibrate.cpp menu_filament.cpp menu_game.cpp menu_info.cpp menu_job_recovery.cpp menu_main.cpp menu_media.cpp menu_mixer.cpp menu_mmu2.cpp menu_mmu2.h menu_motion.cpp menu_spindle_laser.cpp menu_temperature.cpp menu_tmc.cpp menu_tune.cpp menu_ubl.cpp menu_led.cpp menu_power_monitor.cpp
    ../source/Marlin/src/lcd/menu/game/: brickout.h brickout.cpp game.cpp game.h invaders.cpp invaders.h maze.cpp maze.h snake.cpp snake.h types.h
    ../source/Marlin/src/lcd/language/: language_en.h language_an.h language_bg.h language_ca.h language_cz.h language_da.h language_de.h language_el.h language_el_gr.h language_es.h language_eu.h language_fi.h language_fr.h language_gl.h language_hr.h language_hu.h language_it.h language_jp_kana.h language_ko_KR.h language_nl.h language_pl.h language_pt.h language_pt_br.h language_ro.h language_ru.h language_sk.h language_test.h language_tr.h language_uk.h language_vi.h language_zh_CN.h language_zh_TW.h
    ../source/Marlin/src/lcd/dwin/: i2c_eeprom.cpp i2c_eeprom.h dwin.cpp dwin.h dwin_lcd.cpp dwin_lcd.h rotary_encoder.cpp rotary_encoder.h
    ../source/Marlin/src/lcd/dogm/: dogm_Bootscreen.h dogm_Statusscreen.h HAL_LCD_class_defines.h HAL_LCD_com_defines.h lcdprint_u8g.cpp status_screen_DOGM.cpp status_screen_lite_ST7920.cpp status_screen_lite_ST7920.h u8g_dev_ssd1306_sh1106_128x64_I2C.cpp u8g_dev_st7565_64128n_HAL.cpp u8g_dev_st7920_128x64_HAL.cpp u8g_dev_uc1701_mini12864_HAL.cpp u8g_fontutf8.cpp u8g_fontutf8.h ultralcd_DOGM.cpp ultralcd_DOGM.h ultralcd_st7920_u8glib_rrd_AVR.cpp ultralcd_st7920_u8glib_rrd_AVR.h u8g_dev_tft_320x240_upscale_from_128x64.cpp
    ../source/Marlin/src/lcd/dogm/fontdata/: fontdata_ISO10646_1.h langdata_en.h fontdata_6x9_marlin.h langdata_an.h langdata_bg.h langdata_ca.h langdata_cz.h langdata_da.h langdata_de.h langdata_el.h langdata_el_gr.h langdata_es.h langdata_eu.h langdata_fi.h langdata_fr.h langdata_gl.h langdata_hr.h langdata_hu.h langdata_it.h langdata_jp_kana.h langdata_ko_KR.h langdata_nl.h langdata_pl.h langdata_pt.h langdata_pt_br.h langdata_ro.h langdata_ru.h langdata_sk.h langdata_test.h langdata_tr.h langdata_uk.h langdata_vi.h langdata_zh_CN.h langdata_zh_TW.h
    ../source/Marlin/src/lcd/extui/: ui_api.cpp ui_api.h
    ../source/Marlin/src/lcd/extui/lib/anycubic/: anycubic_serial.cpp anycubic_serial.h anycubic_tft.cpp anycubic_tft.h
    ../source/Marlin/src/lcd/extui/lib/dgus/: DGUSDisplay.cpp DGUSDisplay.h DGUSDisplayDef.h DGUSScreenHandler.cpp DGUSScreenHandler.h DGUSVPVariable.h
    ../source/Marlin/src/lcd/extui/lib/dgus/fysetc/: DGUSDisplayDef.cpp
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/: compat.h config.h marlin_events.cpp pin_mappings.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/archim2-flash/: flash_storage.cpp flash_storage.h media_file_reader.cpp media_file_reader.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/ftdi_eve_lib/: ftdi_eve_lib.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/ftdi_eve_lib/extras/: circular_progress.h poly_ui.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/ftdi_eve_lib/extended/: bitmap_info.h command_processor.cpp command_processor.h dl_cache.cpp dl_cache.h event_loop.cpp event_loop.h ftdi_extended.h grid_layout.h polygon.h rgb_t.h screen_types.cpp screen_types.h sound_list.h sound_player.cpp sound_player.h text_box.cpp text_box.h tiny_timer.cpp tiny_timer.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/ftdi_eve_lib/basic/: boards.h commands.cpp commands.h constants.h display_list.h ftdi_basic.h registers_ft800.h registers_ft810.h resolutions.h spi.cpp spi.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/language/: language.cpp language.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/screens/: about_screen.cpp advanced_settings_menu.cpp alert_dialog_box.cpp backlash_compensation_screen.cpp base_numeric_adjustment_screen.cpp base_screen.cpp bed_mesh_screen.cpp bio_advanced_settings.cpp bio_confirm_home_e.cpp bio_confirm_home_xyz.cpp bio_main_menu.cpp bio_printer_ui_landscape.h bio_printer_ui_portrait.h bio_printing_dialog_box.cpp bio_status_screen.cpp bio_tune_menu.cpp boot_screen.cpp case_light_screen.cpp change_filament_screen.cpp confirm_abort_print_dialog_box.cpp confirm_auto_calibration_dialog_box.cpp confirm_erase_flash_dialog_box.cpp confirm_start_print_dialog_box.cpp confirm_user_request_alert_box.cpp default_acceleration_screen.cpp developer_menu.cpp dialog_box_base_class.cpp display_tuning_screen.cpp endstop_state_screen.cpp feedrate_percent_screen.cpp filament_menu.cpp filament_runout_screen.cpp files_screen.cpp interface_settings_screen.cpp interface_sounds_screen.cpp jerk_screen.cpp junction_deviation_screen.cpp kill_screen.cpp language_menu.cpp linear_advance_screen.cpp lock_screen.cpp main_menu.cpp max_acceleration_screen.cpp max_velocity_screen.cpp media_player_screen.cpp move_axis_screen.cpp nozzle_offsets_screen.cpp nudge_nozzle_screen.cpp preheat_menu.cpp preheat_timer_screen.cpp restore_failsafe_dialog_box.cpp save_settings_dialog_box.cpp screen_data.h screens.cpp screens.h spinner_dialog_box.cpp statistics_screen.cpp status_screen.cpp stepper_bump_sensitivity_screen.cpp stepper_current_screen.cpp steps_screen.cpp stress_test_screen.cpp string_format.cpp string_format.h temperature_screen.cpp touch_calibration_screen.cpp touch_registers_screen.cpp tune_menu.cpp widget_demo_screen.cpp z_offset_screen.cpp
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/theme/: bitmaps.h colors.h fonts.h marlin_bootscreen_landscape.h marlin_bootscreen_portrait.h sounds.cpp sounds.h theme.h
    ../source/Marlin/src/lcd/extui/lib/mks_ui/: draw_about.cpp draw_about.h draw_acceleration_settings.cpp draw_acceleration_settings.h draw_advance_settings.cpp draw_advance_settings.h draw_change_speed.cpp draw_change_speed.h draw_dialog.cpp draw_dialog.h draw_eeprom_settings.cpp draw_eeprom_settings.h draw_error_message.cpp draw_error_message.h draw_extrusion.cpp draw_extrusion.h draw_fan.cpp draw_fan.h draw_home.cpp draw_home.h draw_jerk_settings.cpp draw_jerk_settings.h draw_language.cpp draw_language.h draw_machine_para.cpp draw_machine_para.h draw_machine_settings.cpp draw_machine_settings.h draw_manuaLevel.cpp draw_manuaLevel.h draw_max_feedrate_settings.cpp draw_max_feedrate_settings.h draw_motor_settings.cpp draw_motor_settings.h draw_move_motor.cpp draw_move_motor.h draw_number_key.cpp draw_number_key.h draw_operation.cpp draw_operation.h draw_pause_message.cpp draw_pause_message.h draw_pause_position.cpp draw_pause_position.h draw_preHeat.cpp draw_preHeat.h draw_print_file.cpp draw_print_file.h draw_printing.cpp draw_printing.h draw_ready_print.cpp draw_ready_print.h draw_set.cpp draw_set.h draw_step_settings.cpp draw_step_settings.h draw_tmc_current_settings.cpp draw_tmc_current_settings.h draw_tool.cpp draw_tool.h draw_ui.cpp draw_ui.h gb2312_puhui16.cpp mks_hardware_test.cpp mks_hardware_test.h pic_manager.cpp pic_manager.h printer_operation.cpp printer_operation.h SPI_TFT.cpp SPI_TFT.h tft_fsmc.cpp tft_fsmc.h tft_Language_en.h tft_Language_fr.h tft_Language_it.h tft_Language_ru.h tft_Language_s_cn.h tft_Language_sp.h tft_Language_t_cn.h tft_lvgl_configuration.cpp tft_lvgl_configuration.h tft_multi_language.cpp tft_multi_language.h W25Qxx.cpp W25Qxx.h
    ../source/Marlin/src/lcd/HD44780/: lcdprint_hd44780.cpp ultralcd_HD44780.cpp ultralcd_HD44780.h
    ../source/Marlin/src/lcd/extui/lib/ftdi_eve_touch_ui/ftdi_eve_lib/extended/unicode/: font_bitmaps.cpp font_bitmaps.h font_size_t.cpp font_size_t.h README.txt standard_char_set.cpp standard_char_set.h unicode.cpp unicode.h western_char_set.cpp western_char_set.h western_char_set_bitmap_31.h
  group marlin_libs
    ../source/Marlin/src/libs/: BL24CXX.cpp BL24CXX.h bresenham.h buzzer.cpp buzzer.h circularqueue.h crc16.cpp crc16.h duration_t.h hex_print_routines.cpp hex_print_routines.h least_squares_fit.cpp least_squares_fit.h nozzle.cpp nozzle.h numtostr.cpp numtostr.h private_spi.h softspi.h stopwatch.cpp stopwatch.h vector_3.cpp vector_3.h
    ../source/Marlin/src/libs/L64XX/: L64XX_Marlin.cpp L64XX_Marlin.h
    ../source/Marlin/src/libs/heatshrink/: heatshrink_common.h heatshrink_config.h heatshrink_decoder.cpp heatshrink_decoder.h
  group marlin_module
    ../source/Marlin/src/module/: configuration_store.cpp configuration_store.h delta.cpp delta.h endstops.cpp endstops.h motion.cpp motion.h planner.cpp planner.h planner_bezier.cpp planner_bezier.h printcounter.cpp printcounter.h probe.cpp probe.h scara.cpp scara.h speed_lookuptable.h stepper.cpp stepper.h temperature.cpp temperature.h tool_change.cpp tool_change.h servo.cpp
    ../source/Marlin/src/module/stepper/: indirection.cpp indirection.h L64xx.cpp L64xx.h TMC26X.cpp TMC26X.h trinamic.cpp trinamic.h
    ../source/Marlin/src/module/thermistor/: thermistor_1.h thermistor_2.h thermistor_3.h thermistor_4.h thermistor_5.h thermistor_6.h thermistor_7.h thermistor_8.h thermistor_9.h thermistor_10.h thermistor_11.h thermistor_12.h thermistor_13.h thermistor_15.h thermistor_18.h thermistor_20.h thermistor_21.h thermistor_22.h thermistor_23.h thermistor_51.h thermistor_52.h thermistor_55.h thermistor_60.h thermistor_61.h thermistor_66.h thermistor_67.h thermistor_70.h thermistor_71.h thermistor_75.h thermistor_99.h thermistor_110.h thermistor_147.h thermistor_201.h thermistor_202.h thermistor_331.h thermistor_332.h thermistor_501.h thermistor_502.h thermistor_512.h thermistor_666.h thermistor_998.h thermistor_999.h thermistor_1010.h thermistor_1047.h thermistors.h
  group marlin_pins
    ../source/Marlin/src/pins/: pins.h sensitive_pins.h pinsDebug.h pinsDebug_list.h
    ../source/Marlin/src/pins/stm32f1/: pins_CREALITY_V4.h
  group marlin_sd
    ../source/Marlin/src/sd/: cardreader.cpp cardreader.h Sd2Card_sdio.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h Sd2Card.cpp Sd2Card.h
    ../source/Marlin/src/sd/usb_flashdrive/: Sd2Card_FlashDrive.cpp Sd2Card_FlashDrive.h
    ../source/Marlin/src/sd/usb_flashdrive/lib-uhs2/: address.h confdescparser.h hexdump.h printhex.h macros.h masstorage.cpp masstorage.h max3421e.h message.cpp message.h parsetools.cpp parsetools.h README.txt settings.h Usb.cpp Usb.h usb_ch9.h UsbCore.h usbhost.cpp usbhost.h
    ../source/Marlin/src/sd/usb_flashdrive/lib-uhs3/dyn_SWI/: dyn_SWI.h SWI_INLINE.h
    ../source/Marlin/src/sd/usb_flashdrive/lib-uhs3/UHS_host/: macro_logic.h UHS_address.h UHS_hexdump.h UHS_host.h UHS_host_INLINE.h UHS_macros.h UHS_message.h UHS_printf_HELPER.h UHS_printhex.h UHS_settings.h UHS_UNOFFICIAL_IDs.h UHS_usb_ch9.h UHS_USB_IDs.h UHS_UsbCore.h UHS_usbhost.h UHS_util_INLINE.h
    ../source/Marlin/src/sd/usb_flashdrive/lib-uhs3/UHS_host/UHS_BULK_STORAGE/: UHS_BULK_STORAGE.h UHS_BULK_STORAGE_INLINE.h UHS_SCSI.h
    ../source/Marlin/src/sd/usb_flashdrive/lib-uhs3/UHS_host/USB_HOST_SHIELD/: UHS_max3421e.h USB_HOST_SHIELD.h USB_HOST_SHIELD_INLINE.h
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
